File: Project/Plates/naevies plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 257.2 x 76.2 mm, 0 parts

Commit message: v1 production files
Other:
- outline, holes or cut-outs redrawn
